# Keil uVision project gimbal_task.uvprojx, settings and files
target gimbal_task (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: gimbal_task +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__CC_ARM,__FPU_PRESENT =1U
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../APP;../DSP;../DSP/MATHE;../DSP/MATHE/support;../BMI088;../BSP/KALMAN;..\BSP
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Inc/: struct_typedef.h
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group APP
    ../APP/: gimbal_task.h gimbal_task.c shoot_task.c shoot_task.h state_task.c state_task.h vision_task.c vision_task.h imu_task.c imu_task.h
    ../BSP/: bsp_can.c
  group BSP
    ../BSP/: bsp_can.h bsp_flash.c bsp_flash.h bsp_rc.c bsp_rc.h bsp_tr.c bsp_tr.h crc.c crc.h pid.c pid.h remote_control.c remote_control.h kalman.c kalman.h bsp_dwt.c bsp_dwt.h ulitility_tools.c ulitility_tools.h tele_link.c tele_link.h bsp_bull_ctr.c bsp_bull_ctr.h
    ../BSP/KALMAN/: kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h user_lib.c user_lib.h
    ../BSP/ADRC/: ADRC_core.c ADRC_core.h ADRC_user.c ADRC_user.h
  group DSP
    ../DSP/: arm_common_tables.h arm_const_structs.h arm_cortexM4lf_math.lib arm_math.h core_sc000.h core_sc300.h
  group BMI088
    ../BMI088/: BMI088reg.h BMI088Middleware.h BMI088Middleware.c BMI088driver.h BMI088driver.c MadgwickAHRS.h MadgwickAHRS.c
software components: CMSIS:CORE 4.3.0
