# Keil uVision project Chassis_task.uvprojx, settings and files
target Chassis_task (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Chassis_task +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BMI088;../BMI088/MahonyAHRS;../BMI088/MahonyAHRS/inc;../Algo;../DSP/MATHE;../DSP/MATHE/support;../App;../DSP;../BSP;../UI
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BMI088
    ../BMI088/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h AHRS.h AHRS.lib AHRS_middleware.c AHRS_middleware.h
    ../BMI088/MahonyAHRS/inc/: MahonyAHRS.h user_lib.h
    ../BMI088/MahonyAHRS/: MahonyAHRS.c user_lib.c
  group DSP
    ../DSP/: arm_common_tables.h arm_const_structs.h arm_cortexM4lf_math.lib arm_math.h core_sc000.h core_sc300.h
    ../DSP/MATHE/: ave_filter.c ave_filter.h rp_math.c rp_math.h
    ../DSP/MATHE/support/: math_support.c math_support.h
  group BSP
    ../BSP/: bsp_flash.h bsp_can.c bsp_can.h bsp_flash.c bsp_uart.c bsp_uart.h crc.c crc.h motor.c motor.h referee.c referee.h
  group APP
    ../App/: chassis_task.c chassis_task.h INS_task.c INS_task.h power_task.c power_task.h state_task.c state_task.h ui_task.c ui_task.h struct_typedef.h
  group Algo
    ../Algo/: bsp_pid.c bsp_pid.h
  group UI
    ../UI/: priority_ui.c priority_ui.h ui.c ui.h ui_protocol.c ui_protocol.h
software components: CMSIS:CORE 4.3.0
